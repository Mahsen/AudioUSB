# IAR project main.ewp, settings and files
configuration Output (ARM)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: main.hex
  ILINK.IlinkOutputFile: main.out
  ILINK.IlinkIcfFile: main.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    cmsis/: core_cm3.c
  group cmsis_boot
    cmsis_boot/: system_LPC17xx.c
  group Core
    Core/: Process.c
  group Drivers/GLCD
    Drivers/GLCD/: AsciiLib.c GLCD.c
  group Drivers/TouchPanel
    Drivers/TouchPanel/: TouchPanel.c
  group Drivers/USB
    Drivers/USB/: adcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group lpc17xx_lib
    lpc17xx_lib/source/: adc.c clkpwr.c dac.c libcfg.c pinsel.c timer.c uart.c
  group Main
    ./: main.cpp
  group Startup
    Startup/: startup_LPC17xx.s
