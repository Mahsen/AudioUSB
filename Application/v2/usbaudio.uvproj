# Keil uVision project usbaudio.uvproj, settings and files
target Flash (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: usbaudio +hex
  c flags: Optim=1
  c include: ..\Common\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  scatter file: .\DMA.sct
  group Startup Files
    ./common/src/: system_LPC17xx.c core_cm3.c startup_LPC17xx.s
  group USB
    ./Drivers/USB/: adcuser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group MAIN
    ./MAIN/: usbdmain.c
  group UART
    ./Drivers/UART/: uart.c
  group GPU
    ./Drivers/GPU/GLCD/: AsciiLib.c GLCD.c HzLib.c images.c
  group CMSIS_Library
    ./LPC1700CMSIS_Firmware_Library/source/: lpc17xx_dac.c lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_timer.c lpc17xx_clkpwr.c
